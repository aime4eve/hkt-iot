# Keil uVision project LoRaWAN_SmokeAlarm_KWX.uvprojx, settings and files
target LoRaWAN_SmokeAlarm_KWX_Release (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: HT32F52241_48LQFP Holtek
  pack: Holtek.HT32_DFP.1.0.32
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0xFC00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LoRaWAN_SmokeAlarm_KWX +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER,USE_HT32F52231_41, USE_MEM_HT32F52241
  c misc: --C99
  c include: ..\Compents\Lib\Device\Holtek\HT32F5xxxx\Include;..\Compents\Lib\HT32F5xxxx_Driver\inc;..\Compents\Lib\CMSIS\Include;..\Compents\LoRa\include;..\Compents\Modules\include;..\Compents\System;.\Drive\include;..\USER
  asm define: USE_HT32_CHIP=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./: main.c config.h
  group Drive
    ./Drive/: systick.c uart.c tim.c rtc.c communicate.c adc.c gpio.c flash.c
  group System
    ../Compents/System/: ht32_op.s ht32f5xxxx_01_it.c
    ../Compents/Lib/Device/Holtek/HT32F5xxxx/Source/ARM/: startup_ht32f52231_41.s
    ../Compents/Lib/Device/Holtek/HT32F5xxxx/Source/: system_ht32f5xxxx_02.c
  group Modules
    ../Compents/Modules/: lwrb.c
  group LoRa
    ../Compents/LoRa/: LoRaWAN_APPLY.c LoRaWAN_ATCMD.c
  group Lib
    ../Compents/Lib/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_rtc.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_wdt.c ht32f5xxxx_rstcu.c ht32_time.c ht32f5xxxx_pwrcu.c
