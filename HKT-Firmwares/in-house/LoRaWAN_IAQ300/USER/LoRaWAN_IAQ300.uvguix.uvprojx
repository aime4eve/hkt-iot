# Keil uVision project LoRaWAN_IAQ300.uvguix.uvprojx, settings and files
target LoRaWAN_IAQ300_Release (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: FM33A06XEV FMSH
  pack: Keil.FM33A0XXEV_DFP.0.0.4
  cpu: IRAM(0x20000000,0x14000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LoRaWAN_IAQ300 +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __VTOR_PRESENT,TX_ENABLE_STACK_CHECKING,TX_INCLUDE_USER_DEFINE_FILE,TX_ENABLE_FPU_SUPPORT
  c include: ..\USER;.\Drive\include;..\Compents\System;..\Compents\LoRa\include;..\Compents\Lib\Drivers;..\Compents\Lib\CMSIS\Core\Include;..\Compents\Sensor\include;..\Compents\Sensor\Renesas\include;..\Compents\Sensor\Renesas\Driver;..\Compents\Sensor\Renesas\Driver\lib;..\Compents\Sensor\Renesas\Driver\src;..\Compents\Sensor\Renesas\Driver\lib\iaq_2nd_gen\Arm Cortex-M\M0plus\armcc;..\Compents\Sensor\Renesas\Driver\lib\oaq_2nd_gen\Arm Cortex-M\M0plus\armcc;..\Compents\Sensor\Sensirion\include;..\Compents\Sensor\Sensirion\Driver;..\Compents\Modules\include;..\Compents\Modules\Fonts;..\Compents\Modules\FlashDB-1.1.2\inc;..\Compents\Modules\FlashDB-1.1.2\port\fal\inc;..\Compents\Modules\FlashDB-1.1.2\sfud\inc;..\Compents\Modules\FlashDB-1.1.2\src;..\Compents\QRCODE;..\Compents\ThreadX\ports\cortex_m0\ac5\inc;..\Compents\ThreadX\utility\low_power;..\Compents\ThreadX\common\inc
  asm define: TX_ENABLE_FPU_SUPPORT,TX_EXECUTION_PROFILE_ENABLE,TX_ENABLE_EXECUTION_CHANGE_NOTIFY,TX_LOW_POWER
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0x7c000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group User
    ./: main.c config.h tx_user.h tx_port.h
  group Driver
    ./Drive/: adc.c communicate.c control_center.c flash.c gpio.c iic.c spi.c systick.c tim.c trng.c uart.c
  group System
    ../Compents/System/: user_init.c system_FM33A0XXEV.c startup_FM33A0XXEV.s
  group Modules
    ../Compents/Modules/: lwrb.c multi_button.c GUI_Paint.c
  group LoRa
    ../Compents/LoRa/: LoRaWAN_ATCMD.c LoRaWAN_APPLY.c
  group Lib
    ../Compents/Lib/Drivers/: fm33a0xxev_adc.c fm33a0xxev_aes.c fm33a0xxev_bstim.c fm33a0xxev_bt.c fm33a0xxev_cdif.c fm33a0xxev_cmu.c fm33a0xxev_comp.c fm33a0xxev_crc.c fm33a0xxev_dbg.c fm33a0xxev_dma.c fm33a0xxev_et.c fm33a0xxev_flash.c fm33a0xxev_gpio.c fm33a0xxev_hash.c fm33a0xxev_i2c.c fm33a0xxev_iwdt.c fm33a0xxev_lcd.c fm33a0xxev_lptim.c fm33a0xxev_lpuart.c fm33a0xxev_pae.c fm33a0xxev_pmu.c fm33a0xxev_qspi.c fm33a0xxev_rmu.c fm33a0xxev_rng.c fm33a0xxev_rtc.c fm33a0xxev_spi.c fm33a0xxev_svd.c fm33a0xxev_u7816.c fm33a0xxev_uart.c fm33a0xxev_vrtc.c fm33a0xxev_wwdt.c
  group Sensor
    ../Compents/Sensor/: CB_HCHO_V4C.c HP203B.c IM8601PA.c LTR_3XXALS_01.c PMSA003.c SEN0231.c W25X40CLSNIG.c CM1106SL.c EPD.c
    ../Compents/Sensor/Sensirion/: SCD4X.c SGP4X.c SHT40X.c
    ../Compents/Sensor/Renesas/: ZMOD441X.c ZMOD451X.c
    ../Compents/Sensor/include/: image.h
  group Reneasas/Driver
    ../Compents/Sensor/Renesas/Driver/src/: zmod4xxx.c zmod4xxx_i2c_hal.c
    ../Compents/Sensor/Renesas/Driver/lib/iaq_2nd_gen/Arm Cortex-M/M0plus/armcc/: lib_iaq_2nd_gen.lib lib_zmod4xxx_cleaning.lib
    ../Compents/Sensor/Renesas/Driver/lib/oaq_2nd_gen/Arm Cortex-M/M0plus/armcc/: lib_oaq_2nd_gen.lib
  group Sensirion/Driver
    ../Compents/Sensor/Sensirion/Driver/: scd4x_i2c.c sensirion_common.c sensirion_i2c.c sensirion_voc_algorithm.c sgp40_i2c.c sht4x_i2c.c
  group Fonts
    ../Compents/Modules/Fonts/: font_custom.c font8.c font12.c font12CN.c font16.c font16_H_16x11.c font20.c font24.c font24_h_24x12.c font24CN.c font30.c font30_h_30x16.c
  group FlashDB
    ../Compents/Modules/FlashDB-1.1.2/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group FlashDB/Fal
    ../Compents/Modules/FlashDB-1.1.2/port/fal/src/: fal.c fal_flash.c fal_flash_sfud_port.c fal_partition.c fal_rtt.c
  group FlashDB/Sfud
    ../Compents/Modules/FlashDB-1.1.2/sfud/: drv_spi_flash.c
    ../Compents/Modules/FlashDB-1.1.2/sfud/src/: sfud.c sfud_sfdp.c
    ../Compents/Modules/FlashDB-1.1.2/sfud/port/: sfud_port.c
  group QRcode
    ../Compents/QRCODE/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group ThreadX/Ports
    ../Compents/ThreadX/ports/cortex_m0/ac5/src/: tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
    ../Compents/ThreadX/ports/cortex_m0/ac5/example_build/: tx_initialize_low_level.s
  group ThreadX/Source
    ../Compents/ThreadX/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group ThreadX/LowPower
    ../Compents/ThreadX/utility/low_power/: tx_low_power.c
