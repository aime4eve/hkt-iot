# Keil uVision project LoRaWAN_SmartDoorLock_BootLoad.uvprojx, settings and files
target LoRaWAN_SmartDoorLock_BootLoad_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FM33A06XEV FMSH
  pack: Keil.FM33A0XXEV_DFP.0.0.4
  cpu: IRAM(0x20000000,0x14000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LoRaWAN_SmartDoorLock_BootLoad +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __VTOR_PRESENT
  c include: ..\Compents\System;..\Compents\Lib\Drivers;..\Compents\BootLoad;..\Compents\Lib\CMSIS\Core\Include
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group User
    ../Compents/BootLoad/: main.c config.h
  group Driver
    ../Compents/BootLoad/: flash.c gpio.c systick.c tim.c uart.c crc.c
  group System
    ../Compents/System/: user_init.c
    ../Compents/BootLoad/: system_FM33A0XXEV.c startup_FM33A0XXEV.s
  group Lib
    ../Compents/Lib/Drivers/: fm33a0xxev_adc.c fm33a0xxev_aes.c fm33a0xxev_bstim.c fm33a0xxev_bt.c fm33a0xxev_cdif.c fm33a0xxev_cmu.c fm33a0xxev_comp.c fm33a0xxev_crc.c fm33a0xxev_dbg.c fm33a0xxev_dma.c fm33a0xxev_et.c fm33a0xxev_flash.c fm33a0xxev_gpio.c fm33a0xxev_hash.c fm33a0xxev_i2c.c fm33a0xxev_iwdt.c fm33a0xxev_lcd.c fm33a0xxev_lptim.c fm33a0xxev_lpuart.c fm33a0xxev_pae.c fm33a0xxev_pmu.c fm33a0xxev_qspi.c fm33a0xxev_rmu.c fm33a0xxev_rng.c fm33a0xxev_rtc.c fm33a0xxev_spi.c fm33a0xxev_svd.c fm33a0xxev_u7816.c fm33a0xxev_uart.c fm33a0xxev_vrtc.c fm33a0xxev_wwdt.c
