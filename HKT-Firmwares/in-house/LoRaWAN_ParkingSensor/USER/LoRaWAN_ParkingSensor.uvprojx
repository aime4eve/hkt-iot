# Keil uVision project LoRaWAN_ParkingSensor.uvprojx, settings and files
target LoRaWAN_ParkingSensor_Release (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: LoRaWAN_ParkingSensor +hex
  AfterMake: Keil5_disp_size_bar_v0.4.exe
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,USE_FULL_LL_DRIVER,USER_VECT_TAB_ADDRESS
  c include: ..\Compents\Lib\STM32L4xx_HAL_Driver\Inc;..\Compents\Lib\CMSIS\Include;..\Compents\Lib\CMSIS\Device\ST\STM32L4xx\Include;..\Compents\LoRa\include;..\Compents\Modules\lwrb;..\Compents\Modules;..\Compents\System;.\Drive\include;..\USER;..\Compents\Modules\FlashDB-1.1.2\inc;..\Compents\Modules\FlashDB-1.1.2\port\fal\inc;..\Compents\Modules\FlashDB-1.1.2\sfud\inc;..\Compents\Modules\FlashDB-1.1.2\src;..\Compents\CmBacktrace\cm_backtrace;..\Compents\Upgrade
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x2a000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group USER
    ./: main.c config.h cmb_cfg.h
  group Drive
    ./Drive/: adc.c communicate.c control_center.c flash.c gpio.c iic.c systick.c tim.c uart.c rtc.c spi.c rkb1145d.c qmc5883l.c p25q40.c ble_upgrade.c
  group Upgrade
    ../Compents/Upgrade/: upgrade_crc.c upgrade_frame.c upgrade_flash.c app_bspatch.c
    ../Compents/Upgrade/minilzo/: minilzo.c
  group System
    ../Compents/System/: stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c stm32l4xx_hal_conf.h startup_stm32l431xx.s
  group Modules
    ../Compents/Modules/lwrb/: lwrb.c
    ../Compents/Modules/: multi_button.c
  group LoRa
    ../Compents/LoRa/: LoRaWAN_APPLY.c LoRaWAN_ATCMD.c
  group Lib
    ../Compents/Lib/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_dac.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rtc.c stm32l4xx_ll_spi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c
  group FlashDB
    ../Compents/Modules/FlashDB-1.1.2/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group FlashDB/Fal
    ../Compents/Modules/FlashDB-1.1.2/port/fal/src/: fal.c fal_flash.c fal_flash_sfud_port.c fal_partition.c fal_rtt.c
  group FlashDB/Sfud
    ../Compents/Modules/FlashDB-1.1.2/sfud/src/: sfud.c sfud_sfdp.c
    ../Compents/Modules/FlashDB-1.1.2/sfud/port/: sfud_port.c
    ../Compents/Modules/FlashDB-1.1.2/sfud/: drv_spi_flash.c
  group cm_backtrace
    ../Compents/CmBacktrace/cm_backtrace/: cm_backtrace.c
    ../Compents/CmBacktrace/cm_backtrace/fault_handler/keil/: cmb_fault.S
