# Keil uVision project LoRaWAN_ParkingSensor_BootLoader.uvprojx, settings and files
target LoRaWAN_ParkingSensor_BootLoaderr_Release (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: LoRaWAN_ParkingSensor_BootLoader +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,USE_FULL_LL_DRIVER
  c include: ..\Compents\Lib\STM32L4xx_HAL_Driver\Inc;..\Compents\Lib\CMSIS\Include;..\Compents\Lib\CMSIS\Device\ST\STM32L4xx\Include;..\Compents\System;..\Compents\BootLoader;..\Compents\Upgrade
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group USER
    ../Compents/BootLoader/: main.c config.h
  group Drive
    ../Compents/BootLoader/: flash.c gpio.c systick.c tim.c uart.c crclib.c
  group Upgrade
    ../Compents/Upgrade/: upgrade_crc.c upgrade_flash.c
  group System
    ../Compents/System/: stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c stm32l4xx_hal_conf.h startup_stm32l431xx.s
  group Lib
    ../Compents/Lib/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_dac.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rtc.c stm32l4xx_ll_spi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c
