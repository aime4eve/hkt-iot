# Keil uVision project LoRaWAN_THTB_Sensor.uvprojx, settings and files
target LoRaWAN_THTB_Sensor_Release (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LoRaWAN_THTB_Sensor +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx,NDEBUG
  c misc: --C99
  c include: ..\Compents\Lib\STM32L0xx_HAL_Driver\Inc;..\Compents\Lib\STM32L0xx_HAL_Driver\Inc\Legacy;..\Compents\Lib\CMSIS\Include;..\Compents\Lib\CMSIS\Device\ST\STM32L0xx\Include;..\Compents\LoRa\include;..\Compents\Modules\lwrb;..\Compents\Modules;..\Compents\System;.\Drive\include;..\USER;..\Compents\ThreadX\common\inc;..\Compents\ThreadX\ports\cortex_m0\ac5\inc
  asm include: ..\Compents\ThreadX\ports\cortex_m0\ac5\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./: main.c config.h
  group Drive
    ./Drive/: adc.c communicate.c control_center.c flash.c gpio.c gps.c iic.c systick.c tim.c uart.c spi.c rtc.c
  group System
    ../Compents/System/: stm32l0xx_hal_msp.c stm32l0xx_it.c system_stm32l0xx.c startup_stm32l051xx.s
  group Modules
    ../Compents/Modules/: multi_button.c ens210.c lis2dh12.c lis2dh12_reg.c
  group LoRa
    ../Compents/LoRa/: LoRaWAN_ATCMD.c LoRaWAN_APPLY.c
  group Lib
    ../Compents/Lib/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_cortex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_firewall.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_timebase_tim_template.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c
