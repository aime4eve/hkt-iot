# Keil uVision project LoRaWAN_Wireless_Door_Sensor.uvprojx, settings and files
target LoRaWAN_Wireless_Door_Sensor_Release (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LoRaWAN_Wireless_Door_Sensor +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ..\Compents\Lib\STM32L0xx_HAL_Driver\Inc;..\Compents\Lib\STM32L0xx_HAL_Driver\Inc\Legacy;..\Compents\Lib\CMSIS\Include;..\Compents\Lib\CMSIS\Device\ST\STM32L0xx\Include;..\Compents\LoRa\include;..\Compents\Modules\include;..\Compents\System;.\Drive\include;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./: main.c config.h
  group Drive
    ./Drive/: gpio.c tim.c adc.c control_center.c uart.c communicate.c flash.c systick.c
  group System
    ../Compents/System/: stm32l0xx_hal_msp.c stm32l0xx_it.c system_stm32l0xx.c startup_stm32l051xx.s
  group Modules
    ../Compents/Modules/: lwrb.c
  group LoRa
    ../Compents/LoRa/: LoRaWAN_ATCMD.c LoRaWAN_APPLY.c
  group Lib
    ../Compents/Lib/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_ll_adc.c stm32l0xx_ll_crc.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_cortex.c
